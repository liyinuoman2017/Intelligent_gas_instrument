# Keil uVision project Intelligent_gas_instrument.uvprojx, settings and files
target Intelligent_gas_instrument (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L053C8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Intelligent_gas_instrument +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ..\CORE;..\STM32L0xx_HAL_Driver\Inc;..\STM32L0xx_HAL_Driver\Src;..\USER;..\source\senser;..\source\display;..\source\io_manage;..\source\network;..\source;..\source\task_scheduler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c stm32l0xx_it.c
  group task_scheduler
    ../source/task_scheduler/: task_scheduler.c
  group senser
    ../source/senser/: senser_task.c senser_bsp.c
  group display
    ../source/display/: display_task.c display_bsp.c
  group io_manage
    ../source/io_manage/: io_manage_task.c io_manage_bsp.c
  group network
    ../source/network/: network_task.c network_bsp.c
  group core
    ../CORE/: startup_stm32l053xx.s system_stm32l0xx.c
  group lib
    ../STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_adc.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_lcd.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_usart.c
  group readme
    ../source/: readme.txt
